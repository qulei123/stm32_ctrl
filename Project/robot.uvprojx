# Keil uVision project robot.uvprojx, settings and files
target RS232 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RS232 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: "--locale=english"
  c include: ..\Core;..\Driver;..\Main;..\SDK\CMSIS\Include;..\SDK\CMSIS\Device\ST\STM32F1xx\Include;..\SDK\STM32F1xx_HAL_Driver\Inc;..\SDK\STM32F1xx_HAL_Driver\Src;..\Modules\shell;..\Modules;..\Modules\utils;..\Modules\button;..\Driver\BSP;..\Driver\MSP;..\Modules\algorithm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ../Main/: main.c host_link.c common.c core.c user_keys.c
  group Core
    ../Core/: stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_conf.h startup_stm32f103xe.s stm32f1xx_clk.c
  group SDK
    ../SDK/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Modules
    ../Modules/shell/: ansi.c ansi_port.c mod_shell.c nr_micro_shell.c
    ../Modules/button/: flexible_button.c
    ../Modules/utils/: util_log.c util_ow_bitops.c
    ../Modules/: mod_event.c mod_timer.c
    ../Modules/algorithm/: algo_filter.c
  group MSP
    ../Driver/MSP/: drv_adc.c drv_commt_uart.c drv_ctrl_uart.c drv_debug_uart.c drv_delay.c drv_gpio.c drv_msp.c drv_wdg.c drv_timer.c
  group BSP
    ../Driver/BSP/: ds18b20.c isl6251.c motor.c charge.c
